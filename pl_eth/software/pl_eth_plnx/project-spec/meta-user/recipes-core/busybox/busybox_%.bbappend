SRC_URI += "file://user_2024-06-20-01-25-00.cfg"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

